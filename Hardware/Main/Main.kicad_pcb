# Repository waicool20/Divergence-Meter-Project-v2

File README.md:

# Divergence Meter Project v2

This is the second iteration of the [Divergence Meter Project](https://github.com/waicool20/Divergence-Meter-Project) and another personal learning project, this time learning how to integrate Li-Ion batteries into a project, new electrical converter topologies, Rust Programming Language and IoT.

Hardware is mostly finalized and most of the work left to do is actually programming the thing to work like the first program along with IoT capabilities via Android companion app. README will remain brief until I actually finish working on this, stay tuned :)

# Images

# Licenses

Hardware: [Creative Commons Attribution-ShareAlike 4.0 International](https://creativecommons.org/licenses/by-sa/4.0/)  
Software: [GPLv3](https://www.gnu.org/licenses/gpl-3.0.txt)

## KiCad design Hardware/Main/Main.kicad_pcb

Parts:
BZ1: Buzzer; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
C1, C2, C3, C4, C5, C6, C7, C8, C13, C14, C15, C16, C17: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9, C10: 22p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11, C12: 6pf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C43: 2.2u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: LL4148; D_MiniMELF
D2: MMSZ4684 3.3v; D_SOD-123
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad
J1: SWD; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: UART; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: CONN1; PinSocket_1x08_P2.54mm_Vertical
J4: CONN2; PinSocket_1x08_P2.54mm_Vertical
Q1: Si2300; SOT-23
R1: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3, R4, R5, R6, R7, R8, R9, R47: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: Reset; SW_SPST_PTS645
SW2: Boot; SW_SPST_PTS645
U1: DX-BT24
U2: STM32F401RCTx; LQFP-64_10x10mm_P0.5mm
Y1: 8MHz; Crystal_HC49-4H_Vertical
Y2: 32.768kHz; Crystal_C38-LF_D3.0mm_L8.0mm_Horizontal

Connections:
+3V0: C6.2, C14.1, C15.1, C16.1, C17.1, J4.8, R2.1, SW2.2, U1.12, U2.13 (VREF+), U2.19 (VDD), U2.32 (VDD), U2.48 (VDD), U2.64 (VDD); also elsewhere on the board
+5V: J1.1, J2.1; also elsewhere on the board
+12V: J3.6; also elsewhere on the board
+BATT: R9.2; also elsewhere on the board
+HV: J3.8; also elsewhere on the board
/Level Shifter/OUT1: J3.5; also elsewhere on the board
/Level Shifter/OUT2: J3.4; also elsewhere on the board
/Level Shifter/OUT3: J3.3; also elsewhere on the board
/Level Shifter/OUT4: J3.2; also elsewhere on the board
AUX_RX: J2.3, U2.43 (PA10)
AUX_TX: J2.2, U2.42 (PA9)
BATT_INT: U2.2 (PC13); also elsewhere on the board
BATT_SCL: U2.61 (PB8); also elsewhere on the board
BATT_SDA: U2.62 (PB9); also elsewhere on the board
BL: U2.59 (PB7); also elsewhere on the board
BT_CONN: U1.17, U2.15 (PA1)
BT_RX: U1.1, U2.17 (PA3)
BT_TX: U1.2, U2.16 (PA2)
BUTTON1: C3.1, R8.1, U2.21 (PA5)
BUTTON2: C4.1, R7.1, U2.22 (PA6)
BUTTON3: C5.1, R6.1, U2.23 (PA7)
BUTTON4: C7.1, R5.1, U2.24 (PC4)
BUTTON5: C8.1, R4.1, U2.25 (PC5)
BUZZER: Q1.1 (G), R47.1, U2.20 (PA4)
Boot: C2.1, R3.1, SW2.1, U2.60 (BOOT0)
CLK: U2.57 (PB5); also elsewhere on the board
DAT: U2.56 (PB4); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C9.1, C10.1, C11.1, C12.1, C13.2, C14.2, C15.2, C16.2, C17.2, C43.2, D2.2 (A), H1.1, H2.1, H3.1, H4.1, J1.4, J2.4, J3.1, J4.1, Q1.3 (D), R3.2, R47.2, SW1.1, U1.13, U1.14, U1.26, U2.12 (VSSA), U2.18 (VSS), U2.31 (VSS), U2.47 (VSS), U2.63 (VSS); also elsewhere on the board
HV_ENABLE: U2.50 (PA15); also elsewhere on the board
LDR: J4.7, U2.26 (PB0)
LE: U2.58 (PB6); also elsewhere on the board
NRST: C1.1, R2.2, SW1.2, U2.7 (NRST)
unnamed: BZ1.2 (+), D1.2 (A), Q1.2 (S)
unnamed: C9.2, U2.5 (PH0), Y1.2
unnamed: C10.2, U2.6 (PH1), Y1.1
unnamed: C11.2, U2.3 (PC14), Y2.1
unnamed: C12.2, U2.4 (PC15), Y2.2
unnamed: C13.1, D2.1 (K), R9.1, U2.1 (VBAT)
unnamed: C43.1, U2.30 (VCAP1)
unnamed: D1.1 (K), R1.2
unnamed: J4.2, R8.2
unnamed: J4.3, R7.2
unnamed: J4.4, R6.2
unnamed: J4.5, R5.2
unnamed: J4.6, R4.2
SWDCLK: J1.2, U2.49 (PA14)
SWDIO: J1.3, U2.46 (PA13)
USB_DN: U2.44 (PA11); also elsewhere on the board
USB_DP: U2.45 (PA12); also elsewhere on the board
USB_SEL: U2.41 (PA8); also elsewhere on the board
VBUS_DETECT: U2.40 (PC9); also elsewhere on the board
VCC: BZ1.1 (-), R1.1; also elsewhere on the board

Parts:
BT1: 18650 3.7v; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
C18, C21, C23, C26: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C19, C22, C25, C40, C41, C42: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C20, C24, C29: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C27: 47n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C28: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D3: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D6: LL5819; D_MiniMELF
D7: MMSZ4684 3.3v; D_SOD-123
J5: I2C; PinHeader_1x03_P2.54mm_Vertical
JP1: CE; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L1: 4.7u; CD54
P1: USB_C_Plug_USB2.0; USB_C_Receptacle_XKB_U262-16XN-4BVC11
R10, R13, R17, R18, R19, R20, R23, R24: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 1.8M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 18.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14, R15: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16: 0.01; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R21: 140; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R22, R49: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R44, R45: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R46, R48: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW3: PWR; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
TH1: 103AT-2; R_Axial_DIN0204_L3.6mm_D1.6mm_P2.54mm_Vertical
TP1: TP_5V; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP2: DP; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP3: DN; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP4: TP_BATT; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP7: TP_VCC; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
U3: ME6211C30M5; SOT-23-5
U4: BQ27510-G3; Texas_S-PDSO-N12
U5: STF202-22T1G; TSOP-6_1.65x3.05mm_P0.95mm
U6: TS3USB221A; Texas_R-PUQFN-N10
U7: BQ24295; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm_ThermalVias

Connections:
+3V0: C21.1, R10.1, R13.1, R19.2, U3.5, U5.1, U6.10 (VCC); also elsewhere on the board
+5V: C19.2, C20.2, C26.1, D6.2 (A), P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), R46.1, TP1.1, U7.1 (VBUS), U7.24 (VBUS); also elsewhere on the board
+BATT: BT1.1 (+), C23.1, C24.2, TP4.1, U4.3 (REGIN), U4.4 (BAT), U7.13 (BAT), U7.14 (BAT); also elsewhere on the board
BATT_GPOUT: JP1.1 (A), R18.2, U4.12 (GPOUT), U7.9 (~CE)
BATT_INT: R19.1, U7.7 (INT); also elsewhere on the board
BATT_SCL: J5.2, R10.2, U4.11 (SCL), U7.5 (SCL); also elsewhere on the board
BATT_SDA: J5.3, R13.2, U4.10 (SDA), U7.6 (SDA); also elsewhere on the board
CHARGE_DN: U6.2 (1D-), U7.3 (D-)
CHARGE_DP: U6.1 (1D+), U7.2 (D+)
GND: C18.2, C19.1, C20.1, C21.2, C22.2, C23.2, C24.1, C25.2, C26.2, C28.2, C29.1, C40.2, C41.2, D7.2 (A), J5.1, JP1.2 (B), P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), R14.2, R15.2, R16.2, R17.1, R20.1, R21.1, R24.2, R45.1, R48.1, TH1.2, U3.2, U4.6 (VSS), U4.13 (PAD), U5.6, U6.5 (GND), U6.6 (~OE), U7.17 (PGND), U7.18 (PGND), U7.25 (PAD); also elsewhere on the board
unnamed: BT1.2 (-), R16.1, R44.1
unnamed: C18.1, R11.1, U4.2 (REG25), U4.5 (VCC)
unnamed: C22.1, R11.2, R12.1, U4.1 (BI/TOUT)
unnamed: C25.1, R49.1, U4.9 (TS)
unnamed: C27.1, U7.21 (BTST)
unnamed: C27.2, L1.1, U7.19 (SW), U7.20 (SW)
unnamed: C28.1, R23.1, U7.22 (REGN)
unnamed: C40.1, C42.2, R45.2, U4.8 (SRN)
unnamed: C41.1, C42.1, R44.2, U4.7 (SRP)
unnamed: D3.1 (K), R22.1
unnamed: D6.1 (K), U3.1, U3.3
unnamed: P1.A5 (CC1), R15.1
unnamed: P1.A6 (D+), P1.B6 (D+), TP2.1, U5.3
unnamed: P1.A7 (D-), P1.B7 (D-), TP3.1, U5.2
unnamed: P1.B5 (CC2), R14.1
unnamed: R12.2, R49.2, TH1.1
unnamed: R20.2, U7.8 (OTG)
unnamed: R21.2, U7.10 (ILIM)
unnamed: R22.2, U7.4 (STAT)
unnamed: R23.2, R24.1, U7.11 (TS)
unnamed: U5.4, U6.8 (D+)
unnamed: U5.5, U6.7 (D-)
USB_DN: U6.4 (2D-); also elsewhere on the board
USB_DP: U6.3 (2D+); also elsewhere on the board
USB_SEL: R17.2, U6.9 (S); also elsewhere on the board
VBUS_DETECT: D7.1 (K), R46.2, R48.2; also elsewhere on the board
VCC: SW3.2 (B), TP7.1; also elsewhere on the board
VSYS: C29.2, D3.2 (A), L1.2, R18.1, SW3.1 (A), U7.15 (SYS), U7.16 (SYS)

Parts:
C30, C32, C33: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C31, C34, C37: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C35: 470u; CP_Radial_D8.0mm_P3.50mm
C36, C39: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C38: 2.2u 250v; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
D4: SS34; D_SMA-SMB_Universal_Handsoldering
D5: MURS240; D_SMB_Handsoldering
L2: 4.7u; CD54
Q2: Si2300; SOT-23
Q3: SUD70090E-GE3; TO-252-2
R25, R26, R29, R30: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R27, R32: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R28: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R31: 200k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R33: 0.01; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R34: 15k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R35: 2M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
T1: TTRN-0530H
TP5: TP_12V; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP6: TP_HV; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
TP8: TP_GND; TestPoint_THTPad_2.0x2.0mm_Drill1.0mm
U8: LM3481; VSSOP-10_3x3mm_P0.5mm
U9: SX1308; TSOT-23-6
U10: ME6211C30M5; SOT-23-5

Connections:
+3V0: C39.1, U10.5; also elsewhere on the board
+12V: C33.1, D4.1 (K), R31.1, TP5.1; also elsewhere on the board
+HV: C38.1, D5.1 (K), R35.1, TP6.1; also elsewhere on the board
GND: C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, Q2.2 (S), R25.2, R27.2, R32.2, R33.2, R34.2, T1.5, TP8.1, U8.5 (AGND), U8.7 (PGND), U9.2, U10.2; also elsewhere on the board
HV_ENABLE: Q2.1 (G), R27.1; also elsewhere on the board
unnamed: C31.1, U8.9 (VCC)
unnamed: C34.1, R28.1
unnamed: C37.1, Q3.3 (S), R33.1, U8.1 (Isen)
unnamed: D4.2 (A), L2.2, U9.1
unnamed: D5.2 (A), T1.3
unnamed: Q2.3 (D), R29.2, R30.1
unnamed: Q3.1 (G), U8.8 (DR)
unnamed: Q3.2 (D), T1.1
unnamed: R25.1, R26.2, U8.2 (UVLO)
unnamed: R28.2, U8.3 (COMP)
unnamed: R29.1, U8.6 (FA/SYNC/SD)
unnamed: R31.2, R32.1, U9.3
unnamed: R34.1, R35.2, U8.4 (FB)
VCC: C30.1, C32.1, C35.1, C36.1, L2.1, R26.1, R30.2, T1.2, U8.10 (Vin), U9.4, U9.5, U10.1, U10.3; also elsewhere on the board

Parts:
Q4, Q5, Q6, Q7: Si2300; SOT-23
R36, R37, R38, R39, R40, R41, R42, R43: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
+3V0: Q4.1 (G), Q5.1 (G), Q6.1 (G), Q7.1 (G), R36.1, R37.1, R38.1, R39.1; also elsewhere on the board
+12V: R40.1, R41.1, R42.1, R43.1; also elsewhere on the board
/Level Shifter/OUT1: Q4.3 (D), R40.2; also elsewhere on the board
/Level Shifter/OUT2: Q5.3 (D), R41.2; also elsewhere on the board
/Level Shifter/OUT3: Q6.3 (D), R42.2; also elsewhere on the board
/Level Shifter/OUT4: Q7.3 (D), R43.2; also elsewhere on the board
BL: Q7.2 (S), R39.2; also elsewhere on the board
CLK: Q5.2 (S), R37.2; also elsewhere on the board
DAT: Q4.2 (S), R36.2; also elsewhere on the board
LE: Q6.2 (S), R38.2; also elsewhere on the board

Board: 2 copper layers, 89.3 x 52.1 mm, 146 parts (42 on the bottom side), 91 nets.

## KiCad design Hardware/Nixie/Nixie.kicad_pcb

Parts:
C1, C2, C3: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4, H5, H6: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad
J1: CONN1; PinHeader_1x08_P2.54mm_Vertical
J2: CONN2; PinHeader_1x08_P2.54mm_Vertical
N1, N2, N3, N4, N5, N6, N7, N8: IN-14
R1: LDR 5516 ( 5-10k ); R_LDR_7x6mm_P5.1mm_Vertical
R2: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4, R5, R6, R7, R8, R9, R10: 22k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11, R12, R13, R14, R15: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8: 50k; 3362P
SW1: BUTTON1; SW_SPST_PTS645
SW2: BUTTON2; SW_SPST_PTS645
SW3: BUTTON3; SW_SPST_PTS645
SW4: BUTTON4; SW_SPST_PTS645
SW5: BUTTON5; SW_SPST_PTS645
U1, U2, U3: HV5622-PG; MQFP-44_10x10mm_P0.8mm

Connections:
+3V0: J2.8, R1.1, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2
+12V: C1.1, C2.1, C3.1, J1.6, U1.27, U1.30, U2.27, U2.30, U3.27, U3.30
+HV: J1.8, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1
BUTTON1: J2.2, R15.1, SW1.1
BUTTON2: J2.3, R14.1, SW2.1
BUTTON3: J2.4, R13.1, SW3.1
BUTTON4: J2.5, R12.1, SW4.1
BUTTON5: J2.6, R11.1, SW5.1
GND: C1.2, C2.2, C3.2, H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, J1.1, J2.1, R2.2, R11.2, R12.2, R13.2, R14.2, R15.2, U1.29, U2.29, U3.29
unnamed: J1.2, U1.33, U2.33, U3.33
unnamed: J1.3, U1.31, U2.31, U3.31
unnamed: J1.4, U1.28, U2.28, U3.28
unnamed: J1.5, U1.32
unnamed: J2.7, R1.2, R2.1
unnamed: N1.1 (A), RV1.2
unnamed: N1.2 (LDP), U1.22
unnamed: N1.3 (1), U1.21
unnamed: N1.4 (2), U1.20
unnamed: N1.5 (3), U1.19
unnamed: N1.6 (4), U1.18
unnamed: N1.7 (5), U1.17
unnamed: N1.8 (6), U1.16
unnamed: N1.9 (7), U1.15
unnamed: N1.10 (8), U1.14
unnamed: N1.11 (9), U1.13
unnamed: N1.12 (0), U1.12
unnamed: N1.13 (RDP), U1.11
unnamed: N2.1 (A), RV2.2
unnamed: N2.2 (LDP), U1.10
unnamed: N2.3 (1), U1.9
unnamed: N2.4 (2), U1.8
unnamed: N2.5 (3), U1.7
unnamed: N2.6 (4), U1.6
unnamed: N2.7 (5), U1.5
unnamed: N2.8 (6), U1.4
unnamed: N2.9 (7), U1.3
unnamed: N2.10 (8), U1.2
unnamed: N2.11 (9), U1.1
unnamed: N2.12 (0), U1.44
unnamed: N2.13 (RDP), U1.43
unnamed: N3.1 (A), RV3.2
unnamed: N3.2 (LDP), U1.42
unnamed: N3.3 (1), U1.41
unnamed: N3.4 (2), U1.40
unnamed: N3.5 (3), U1.39
unnamed: N3.6 (4), U1.38
unnamed: N3.7 (5), U1.37
unnamed: N3.8 (6), U1.36
unnamed: N3.9 (7), U1.35
unnamed: N3.10 (8), U2.22
unnamed: N3.11 (9), U2.21
unnamed: N3.12 (0), U2.20
unnamed: N3.13 (RDP), U2.19
unnamed: N4.1 (A), RV4.2
unnamed: N4.2 (LDP), U2.18
unnamed: N4.3 (1), U2.17
unnamed: N4.4 (2), U2.16
unnamed: N4.5 (3), U2.15
unnamed: N4.6 (4), U2.14
unnamed: N4.7 (5), U2.13
unnamed: N4.8 (6), U2.12
unnamed: N4.9 (7), U2.11
unnamed: N4.10 (8), U2.10
unnamed: N4.11 (9), U2.9
unnamed: N4.12 (0), U2.8
unnamed: N4.13 (RDP), U2.7
unnamed: N5.1 (A), RV5.2
unnamed: N5.2 (LDP), U2.6
unnamed: N5.3 (1), U2.5
unnamed: N5.4 (2), U2.4
unnamed: N5.5 (3), U2.3
unnamed: N5.6 (4), U2.2
unnamed: N5.7 (5), U2.1
unnamed: N5.8 (6), U2.44
unnamed: N5.9 (7), U2.43
unnamed: N5.10 (8), U2.42
unnamed: N5.11 (9), U2.41
unnamed: N5.12 (0), U2.40
unnamed: N5.13 (RDP), U2.39
unnamed: N6.1 (A), RV6.2
unnamed: N6.2 (LDP), U2.38
unnamed: N6.3 (1), U2.37
unnamed: N6.4 (2), U2.36
unnamed: N6.5 (3), U2.35
unnamed: N6.6 (4), U3.22
unnamed: N6.7 (5), U3.21
unnamed: N6.8 (6), U3.20
unnamed: N6.9 (7), U3.19
unnamed: N6.10 (8), U3.18
unnamed: N6.11 (9), U3.17
unnamed: N6.12 (0), U3.16
unnamed: N6.13 (RDP), U3.15
unnamed: N7.1 (A), RV7.2
unnamed: N7.2 (LDP), U3.14
unnamed: N7.3 (1), U3.13
unnamed: N7.4 (2), U3.12
unnamed: N7.5 (3), U3.11
unnamed: N7.6 (4), U3.10
unnamed: N7.7 (5), U3.9
unnamed: N7.8 (6), U3.8
unnamed: N7.9 (7), U3.7
unnamed: N7.10 (8), U3.6
unnamed: N7.11 (9), U3.5
unnamed: N7.12 (0), U3.4
unnamed: N7.13 (RDP), U3.3
unnamed: N8.1 (A), RV8.2
unnamed: N8.2 (LDP), U3.2
unnamed: N8.3 (1), U3.1
unnamed: N8.4 (2), U3.44
unnamed: N8.5 (3), U3.43
unnamed: N8.6 (4), U3.42
unnamed: N8.7 (5), U3.41
unnamed: N8.8 (6), U3.40
unnamed: N8.9 (7), U3.39
unnamed: N8.10 (8), U3.38
unnamed: N8.11 (9), U3.37
unnamed: N8.12 (0), U3.36
unnamed: N8.13 (RDP), U3.35
unnamed: R3.2, RV1.1
unnamed: R4.2, RV2.1
unnamed: R5.2, RV3.1
unnamed: R6.2, RV4.1
unnamed: R7.2, RV5.1
unnamed: R8.2, RV6.1
unnamed: R9.2, RV7.1
unnamed: R10.2, RV8.1
unnamed: U1.23, U2.32
unnamed: U2.23, U3.32

Board: 2 copper layers, 172.2 x 52.1 mm, 50 parts (2 on the bottom side), 128 nets.

## Commit log

2021-05-04 Migrate to rtic 0.6
